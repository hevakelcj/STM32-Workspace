# Keil uVision project CppDemo.uvproj, settings and files
target CppDemo (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CppDemo
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\..\..\SourceStore\ucos-ii\port;..\..\..\SourceStore\ucos-ii\core;..\..\..\SourceStore\drive;..\..\..\SourceStore\tinySH;..\code\global;..\USER\App;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\SourceStore\other;..\..\..\SourceStore\CppObject
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT6: RAM 0x80000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group stm-lib
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_dma.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_iwdg.c stm32f10x_sdio.c stm32f10x_pwr.c stm32f10x_fsmc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c misc.c
  group drive
    ../../../SourceStore/Drive/: IRQHandler.cpp bsp_init.c delay.c fsmc_sram.c misc_init.c spin_lock.c stream.c usart.c usart_file.c watchdog.c
  group user
    ../CODE/user/: main.cpp
  group object
    ../../../SourceStore/CppObject/: CDebug.cpp CMsgQueueTask.cpp CShellTask.cpp CStartTask.cpp CTask.cpp CWDGFeedTask.cpp
  group ucos-core
    ../../../SourceStore/ucos-ii/core/: UCOS_II.C
  group ucos-port
    ../../../SourceStore/ucos-ii/port/: app_hook.c os_cpu_c.c os_cpu_a_arm.asm
  group tinySH
    ../../../SourceStore/tinySH/: shell.c shell_code.c shell_nodes.c
    ../../../SourceStore/tinySH/sh_nodes/: sh_debug.c sh_sbin.c
  group sh-nodes
    ../CODE/user/: sh_root.c
  group other
    ../../../SourceStore/other/: utility.c
  group doc
    ../doc/: 修改记录.txt
